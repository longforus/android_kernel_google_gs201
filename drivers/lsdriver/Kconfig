## drivers/lsdriver/Kconfig
```kconfig
config LSDRIVER
    tristate "LSDriver example module"
    default y
    help
      This is a simple example driver for demonstration.
```
